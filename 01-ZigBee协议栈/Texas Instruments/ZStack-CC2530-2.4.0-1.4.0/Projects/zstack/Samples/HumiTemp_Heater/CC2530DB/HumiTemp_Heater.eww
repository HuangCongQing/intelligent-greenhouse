<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HumiTemp_Heater.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HumiTemp_Heater</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>HumiTemp_Heater</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>HumiTemp_Heater</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


